# IAR project mlx90614_irtemp_sensor.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; FRDM_K64F; FREEDOM; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ..; ../board; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/utilities/str; ../../../../../devices/MK64F12/utilities/debug_console; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../devices/MK64F12/drivers; ../../../../../components/lists; ../../../../../components/serial_manager; ../../../../../devices/MK64F12/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: mlx90614_irtemp_sensor.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=0; FRDM_K64F; FREEDOM; SERIAL_PORT_TYPE_UART=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group source
    ../: mlx90614_irtemp_sensor.c mlx90614.c mlx90614.h
  group board
    ../board/: pin_mux.c pin_mux.h
    ../: board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_flash.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_clock.c fsl_clock.h fsl_port.h fsl_uart.c fsl_uart.h fsl_smc.c fsl_smc.h fsl_common.c fsl_common.h
  group utilities
    ../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK64F12/utilities/: fsl_assert.c
  group device
    ../../../../../devices/MK64F12/: MK64F12.h MK64F12_features.h fsl_device_registers.h system_MK64F12.c system_MK64F12.h
  group component/uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MK64F12/iar/: startup_MK64F12.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
