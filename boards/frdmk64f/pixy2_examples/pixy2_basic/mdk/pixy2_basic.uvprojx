# Keil uVision project pixy2_basic.uvprojx, settings and files
target pixy2_basic debug (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: pixy2_basic.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MK64FN1M0VLL12, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, FRDM_K64F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../..;../../../../../CMSIS/Include;../../../../../devices;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../middleware/pixy2/src/link/dspi;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/utilities/str;../../../../../devices/MK64F12/utilities/debug_console;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12/drivers;../../../../../devices/MK64F12;../../../../../components/uart;../../../../../components/serial_manager;../../../../../devices/MK64F12/drivers;../../../../../components/lists;../../../../../components/serial_manager;../../../../../middleware/pixy2/src;../../../../../devices/MK64F12/utilities
  asm define: DEBUG
  asm include: ../../../../src/pixy2_examples/pixy2_basic;..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group source
    ../: pixy2_basic.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_port.h fsl_sim.c fsl_sim.h fsl_clock.c fsl_clock.h fsl_dspi.c fsl_dspi.h fsl_flash.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_gpio.c fsl_gpio.h fsl_uart.c fsl_uart.h fsl_smc.c fsl_smc.h fsl_common.c fsl_common.h
  group pixy2-src-link-dspi
    ../../../../../middleware/pixy2/src/link/dspi/: Pixy2_DSPI.c Pixy2_DSPI.h
  group utilities
    ../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/MK64F12/utilities/: fsl_assert.c
  group device
    ../../../../../devices/MK64F12/: MK64F12.h MK64F12_features.h fsl_device_registers.h system_MK64F12.c system_MK64F12.h
  group component-uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group component-serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component-lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../../../../devices/MK64F12/arm/: startup_MK64F12.s
  group CMSIS
    ../../../../../CMSIS/Include/: core_cm4.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h arm_common_tables.h arm_const_structs.h arm_math.h
  group pixy2-src
    ../../../../../middleware/pixy2/src/: Pixy2Cam.c Pixy2Cam.h
target pixy2_basic release (ARM-ADS)
  device: MK64FN1M0VLL12 NXP
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: pixy2_basic.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MK64FN1M0VLL12, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0, FRDM_K64F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: as above
  c include: as above
  asm define: NDEBUG
  asm include: ../../../../src/pixy2_examples/pixy2_basic;..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: MK64FN1M0xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
